# Keil uVision project MDK.uvprojx, settings and files
target MDK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: MDK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../APP;../MOTOR;../TIME;../SENSOR;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../task;../mydefinition;../myNVIC
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: MDK\MDK.sct
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ./: startup_stm32f750xx.s
    ../Core/Src/: system_stm32f7xx.c
  group APP
    ../APP/: catch.c user.c user.h action_control.c action_control.h warehouse_app.c warehouse_app.h
  group MOTOR
    ../MOTOR/: motor_control.c motor.c imu_control.c pid.c postion_control.c circle_control.c delay.c delay.h telescopic_boom.c telescopic_boom.h
  group SENSOR
    ../SENSOR/: IMU.C QR_code.c circe.c GO-M8010-6.c tjc_usart_hmi.c tjc_usart_hmi.h
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group task
    ../task/: start_task.c start_task.h chassis_control_task.c chassis_control_task.h main_task.c main_task.h action_sets.c action_sets.h catch_yuanpanji_task.c catch_yuanpanji_task.h imu_task.c imu_task.h
  group mydefinition
    ../mydefinition/: Struct_encapsulation.h fast_math.c fast_math.h
  group mynvic
    ../myNVIC/: mynvic.c
software components: CMSIS:CORE 5.5.0
